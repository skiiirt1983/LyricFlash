#pragma once
#include <stdint.h>
/* Genuine serif, ornamental serif and rounded digit shapes sampled from
 * SIL-OFL EB Garamond, Noto Serif Display and Comfortaa. Open-licensed
 * glyph-only 15x21 rasters; no TTF/OTF files distributed.
 * Four additional real open-licensed letterforms: Cabin Bold, Comic Neue Bold,
 * Noto Serif Display ExtraCondensed ExtraBold Italic, Go Mono.
 * Attribution/licensing: docs/CLOCK_FONT_CREDITS.md. */
#define LF_OPEN_FACE_W 15U
#define LF_OPEN_FACE_H 21U
#define LF_OPEN_FACE_FAMILIES 7U
#define LF_OPEN_FACE_RAW_BYTES 2940U
static const char lf_open_face_b64[]="AAAAAAAAAADgA3gGHAwMGAYYBhAGEAwYDBg4DvAH4AMAAAAAAAAAAAAAAAD4H/gf4AfAA8ADwAPAA8ADwAPAA8ADwAPAA8ADwAPAA+AH+B/8HwAAAAAAAAAA4APwB3gMOBg4ADAAcABgAMAAgAEGAw4G/A/8HwAAAAAAAAAAAADgA/AH8AxwCHAAcABgAMAA4APwB3gAOAA4ADgAMAAwAGAAwA8AHwAAAAAAAGAAYADgAOABYANgAmAEYAxgGPwf/B9gAGAAYABgAEAAAAAAAAAAAAAAAPgA8AEAAwAHAA+AD8AH4AHgAPAAcABwAGAAYADAAIAPAB8ADAAAAAAIAHgA4ADAAYADAAcADvAfeB4cHB4cDhwOHA4cDBwcDrgH4AMAAAAAAAD8D/wf+B8YEDAQMABgAEAAwACAAIABAAEAAwACAAYABAAMABgAGAAAAADgA/AHOA4YDBgcGA4wD+AHwAPgA/AHeA44HDwcHBwcHDgc8A/ABwAAAAAAAPADOAccDhwcDhwOHA4YHBwcHDwP+ANwAOAAwAGABwAeABAAAAAAAABgA3APOA48HjwePD48Pj4+Pj4+Pj4+PD48PjwePB44HnAOYAMAAAAAAADwAPAB8AfwPfAZ8AHwAfAB8AHwAfAB8AHwAfAB8AHwAfAB8AMAAAAAAABABngeeBw8PDw8PBx8AHgAcADgAMAAAAEABgAABhD+P/w//D8AAAAAAAAAAGACeA58HHwcfBx8AHgA4ADwADwAPAA+AD4YPDg8GHgcYAwAAAAAAAAAAPgA+AD4APgA+AD4APgA+AD4APgA+AD+P/4/+AD4APgA+AEAAAAAAAD8D/wP/A8EAAAAAAAAAPAAeAA8AD4APgA+AD4YPDg8OHgY4AQAAAAAAAAwATwHHA4cDhgeAB4AHng+PD48Pj4+Pj4+Hj4ePB48DjgGcAMAAAAAAAD+P/4//j/8PwAgAAAIABgAEAAwACAAYADAAMAAwAGAAYADAAMABwAAAABgAjgOPBw8HDwePB44H7AP4Af4A/wOfhw+PB48HjwcPDgcMAYAAAAAAABAAzAOOB48Hjw+Pj4+Pj4+Pj4+Hj4PPgM+ADwAPBg8GDgYcBjABAAAAADAA/APcA44HBgYHDgcOBw4HDgcOBw4HDgcOBw4OBw4HPAP8A/AAwAAAABgAPAD8AdwA3AAcABwAHAAcABwAHAAcABwAHAAcABwAHAAcABgAAAAAADAA/APcB44HBgYGDgYGDgAMABwAOAAwAGAA4ADAAcADgAc/D/4HwAAAADgA/APeA4YHBgYGBg4AHAA4AHwADgAHAAcMAw4HDgcGHge8A/gAwAAAAAAABAAOAB4APgA+AG4ATgDOAc4DjAM/B/+PzgAMAA4ABAAAAAAAAAAAAD8D/wfABwAHAAcAByAH/Af+A8cAA4ADhAOOA44DhgcHDwP+AfgAwAAAABgAOAAwADAAYADgAMAB8AH8A94DjgcGBgcOBw4GBg4HHge8A/AAwAAAAD4P/w/OAA4ADAAcABgAOAAwADAAcABgAOAAwAHAAcADgAOAAwADAAAAADAA/APcA44HDgcOBxwDvAP8A94HjgcHDgcOBw4HDg4HHge8A/AAwAAAADAB/APeB44OBw4HDAcMBg4OBzwH/AP4ADgAMABgAOAAwAHAAcABgAAAAAAAAAA4AfwD/gfPDwcOBw4HDgceBw4HDgcODw8+B/wD+AHAAAAAAAA8ADwAPAD8AfwB/AH8ADwAPAA8ADwAPAA8ADwAPAA8ADwAPAA8ADwAAAA4Af4D/gffBw8EDwQPAA8AHgAeADwAPAA4AHgAcADgAf8B/4P/h/+HwAA4Af4H/gPfAw8ADwAPAB8APgH+Af8BzwAHgAeAB4APhD8H/w/+D/gDwAAAABwAPAA8ADwAfAB8ANwB3AHcA5wHPwf/D/8f3AAcABwAHAAcAAAAAAA+A/4D/gf8B8AHgAeABzAH/Af+B/8ATwAPAA8ADwAfCD4P/g/8D/AHwAAAADgAPABwAeABwAPAB4AHAA88D/4P3w/PDwcOBw4PDx8Pvgf8B/ABwAA/n/8f/x/+D94APAA8ADwAeAB4AHAA8ADgAeAB4AHAA8ADwAeAB4APgAAAADgB/gP/B88HBwcPBw4HPgf8A/4D3weHjweOB44Hjg8PPw/+B/gBwAA4Af4D/wffD88PB54HngeeD48/j/8H/wPPAA4AHgA8ADwAeADwA8ABwAAAACAAeAH8A94HjgcHDgcOBwwDHAMcBxwHHAcOBg4ODzwHvAPwAcAAAAAAADAAcADwAfAD8APwA/AAcABwAHAAcABwAHAAcABwAHAAfAP+A/4DwAAgADwB/gP+B8cPBwYHAA8AHgA+ADwAcAHgA8ADwAeABwAHPw//D/8PwAAgADwB/gPfA8cABwAPAD4APgB+AF8ABwAHgAOAB4YHBz8H/gP8AcAAAAAEAA4AHgAeAD4APgA+AH4A7gDuAc4DzgO/B/+H/wfOAA4ADgAOAAAAAAAAAD8D/wP+A8AHMAe8B/4HzwfHhwOAA4ADgAOAB4YPDz4H/gP4AcAAAAAIADwAPAB4AOABwAPwA/4H/wfPB8eHA44DjgOHB4cHBz8D/gP8AMAAAAAAAD+H/4f/A88ADgAeABwAPAA4ADgAcABwAOAA4AHAAcADwAOAA4AAAAAgADwB/gPfB8cHBwcPBz4D/AP8Af4DzweHDwcOBw4HDz8H/gP4AcAAAAAwAHwB/gPfB8cHAwcDjgOOA4YHhz8H/wP/Ac4AHgA8ADgA8AHAAcAAAAAsAEYBxwPHA4cHh4eHjwePDw8PHw8fDx4PHg4eHh4eHhwOOA4wBiADQAAHAA4APgA+Af4BvgE8ADwAPAA8AHgAeAB4AHgAeADwAPAA8ADwAPgDwAAAAC4AZwDHgceBx4HPAM8ADgAcADgAIABAAMABgAICBD4P/g/8D8AAAAAAAC4ATwHHA8+Dj4OPAA8AHgA4ADgAHAAeAB4AHgAeDB4cPBw4DiAHQAAAAA8ADwAPAA8AHgAeAB4AHgAeADwAPAA8AD8P/w/4AHgAeAB4APgBwAAAAD+A/4H/gcEAAAAAAAAAMAB8Ah4AHgAeAB4AHgQeDBwcPAw4DCAGQAAAAC4ABwDHgccDhgeAB4AHOA8cDx4PHg8eDx4OHg4eDhwOHA44ByADQAA/h/8H/w/CDAIIBAAMAAgAGAAwADAAIABgAMAAwAHAA4ADgAcADwAOAAAAAC4ARwHHAceDx4PHA8cD5gH4AfwA/gPeBw4PDw4PDg4ODg4cBjADgAAAACwATgHHA4cDhweHB4cHhwePB48DjwHPAA4AHgAcDBwMOAwwDAAGwAAgAPgD3AcOBgYOBw4PDB8cMxwjHEMcwxzHH4cPBw4GDg4GHAc4A+AAwAAAAAAAIABgA+AP4BxgAGAAYABgAGAAYABgAGAAYABgAGAAYAB/D/8fwAAgAPwH3A8ODAYMBgwGAA4ADgAcADgAMABgAMABwAOABwAGPg//D/8PwAAgAfwH3AYOBg4GDgAOABwAOAAwA/wATgAGAAcABwQGBA4EHAY4B+ABwAAAABwAPAA8AHwAXADcAZwBnAMcBhwGHAw/H/8f3Q/cABwAHAA/AP8AwAA+B/4H/AfABgAGAAYABgAH+Af8AF4ADgAOAAYADgAOBA4GPAY4B8ADwAA4AD4BxwOCBwMHAA4ADjgOfA3OD4cPAw4DDgMOAw4HDgcHDgO8AfAAQAA/D/8P/w/HAAYADAAcABgAMAAwACAAYADgAMABwAHAAcADgAOAA4ADgAA4AH4BxwODAwMHAwcHA44D/AH8AP4BnwMHhwOGA4YDhgOHBwO+AfAAQAAwAHwBzgOHBwcGAw4DjgOOA44Hhg+HO4PzgMMABwAHBg4GHAc4B+AAwAA";
static inline uint8_t lf_open_face_val(char c)
{
    if(c>='A'&&c<='Z')return (uint8_t)(c-'A');
    if(c>='a'&&c<='z')return (uint8_t)(c-'a'+26);
    if(c>='0'&&c<='9')return (uint8_t)(c-'0'+52);
    if(c=='+')return 62U;
    return 63U;
}
static inline uint8_t lf_open_face_byte(unsigned off)
{
    if(off>=LF_OPEN_FACE_RAW_BYTES)return 0;
    unsigned p=(off/3U)*4U;
    uint32_t x=((uint32_t)lf_open_face_val(lf_open_face_b64[p])<<18)|
         ((uint32_t)lf_open_face_val(lf_open_face_b64[p+1])<<12)|
         ((uint32_t)lf_open_face_val(lf_open_face_b64[p+2])<<6)|
         (uint32_t)lf_open_face_val(lf_open_face_b64[p+3]);
    return (uint8_t)((x>>(16U-8U*(off%3U)))&255U);
}
static inline uint16_t lf_open_face_row(unsigned family,unsigned digit,unsigned y)
{
    if(family>=LF_OPEN_FACE_FAMILIES||digit>=10||y>=LF_OPEN_FACE_H)return 0;
    unsigned p=2U*(family*10U*LF_OPEN_FACE_H+digit*LF_OPEN_FACE_H+y);
    return (uint16_t)(lf_open_face_byte(p)|
                      ((uint16_t)lf_open_face_byte(p+1U)<<8));
}
